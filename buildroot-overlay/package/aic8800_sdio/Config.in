## buildroot-overlay/package/aic8800_sdio/Config.in
```kconfig
config BR2_PACKAGE_AIC8800_SDIO
    bool "AIC8800 SDIO"
    help
        AIC8800 SDIO
```
